Commit message: comments from git stash

File: resources/panda/panda_spherized.urdf (robot description, URDF)
Before this commit: robot panda, 13 links, 12 joints
Joints:
- removed joint panda_finger_joint1
- removed joint panda_finger_joint2
- removed joint panda_grasptarget_hand
